# Keil uVision project 821008.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CS32L010F6 CHIPSEA
  pack: CHIPSEA.CS32L010_DFP.1.0.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 821008 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress 1295
  c include: ..\CMSIS\Device\CS32L010\Include;..\CMSIS\Include;..\CS32L010_HAL_Driver\Inc;..\..\821008__Source_Code;..\SYSTEM;..\APP;..\Lib
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../CMSIS/Device/CS32L010/Source/: system_cs32l010.c
    ../CMSIS/Device/CS32L010/Source/ARM/: startup_cs32l010.s
  group HAL
    ../CS32L010_HAL_Driver/Src/: cs32l010_hal.c cs32l010_hal_adc.c cs32l010_hal_awk.c cs32l010_hal_basetim.c cs32l010_hal_clktrim.c cs32l010_hal_cortex.c cs32l010_hal_crc.c cs32l010_hal_gpio.c cs32l010_hal_i2c.c cs32l010_hal_owire.c cs32l010_hal_pwr.c cs32l010_hal_rcc.c cs32l010_hal_tim.c cs32l010_hal_uart.c
  group app
    ../APP/: CCC_i2c.c CCC_i2c_COPY_22.c SW3516H.C SW3516H_User.C
  group user
    ../: main.c cs32l010_it.c cs32l010_hal_msp.c
